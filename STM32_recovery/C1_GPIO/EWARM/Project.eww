<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\C1_GPIO.ewp</path>
  </project>
  <batchBuild />
</workspace>
